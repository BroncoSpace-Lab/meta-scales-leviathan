IMAGE_INSTALL:append = " imx-static-ip"
IMAGE_INSTALL:append = " imx-deployment"
IMAGE_INSTALL:append = " screen"
IMAGE_INSTALL:append = " watchdogtimer"


